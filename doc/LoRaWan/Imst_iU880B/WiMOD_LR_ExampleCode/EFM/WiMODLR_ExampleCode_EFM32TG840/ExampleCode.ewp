# IAR project ExampleCode.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32TG840F32 EnergyMicro EFM32TG840F32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EFM32TG840F32; iM880A
  ICCARM.CCIncludePath2: CMSIS\Include; Device\SiliconLabs\EFM32TG\Include; emlib\inc; BSP; Driver\LDD; Driver\PDD; 
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: CMSIS\Include; Device\SiliconLabs\EFM32G\Include; emlib\inc; 
  OBJCOPY.OOCOutputFile: maini.bin
  ILINK.IlinkOutputFile: main.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: EFM32G890F128 Silicon Labs EFM32G890F128
  ICCARM.CCDefines: NDEBUG; EFM32G890F128
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: usart-spi.bin
  ILINK.IlinkOutputFile: usart-spi.out
  group (top)
    ./: ComSlip.c ComSlip.h CRC16.c CRC16.h iM880A_RadioInterface.c iM880A_RadioInterface.h main.c RadioDefs.h
  group BSP
    BSP/: bsp.h bsp_defs.h bsp_STK3300_config.h
  group CMSIS
    Device/SiliconLabs/EFM32TG/Source/IAR/: startup_efm32tg.s
    Device/SiliconLabs/EFM32TG/Source/: system_efm32tg.c
  group emlib
    emlib/src/: em_cmu.c em_emu.c em_gpio.c em_system.c em_timer.c em_usart.c
  group LDD
    Driver/LDD/: LDDUsart.c LDDUsart.h
  group PDD
    Driver/PDD/: PDDDelayTimer.c PDDDelayTimer.h PDDUsart.c PDDUsart.h
